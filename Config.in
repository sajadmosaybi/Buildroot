## Config.in
```kconfig
config BR2_PACKAGE_MY_CLI
    bool "my_cli"
    help
      Simple CLI program that runs on startup.
```
